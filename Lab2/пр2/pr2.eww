<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pr2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pr22.ewp</path>
    </project>
    <batchBuild />
</workspace>
